options:
  parameters:
    generate_options: qt_gui
    id: date20230411_rec2_trim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_rate_manchester
  id: variable
  parameters:
    value: '160000'
  states: {}
- name: baud_rate_sego
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: center_offset
  id: variable
  parameters:
    value: '287000'
  states: {}
- name: channel_bw
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '"0101010101010101011100111010"'
  states: {}
- name: timelen
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: variable_band_pass_filter_taps_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '4'
    high_cutoff_freq: baud_rate_manchester
    low_cutoff_freq: '-baud_rate_manchester'
    samp_rate: samp_rate
    type: complex_band_pass
    width: baud_rate_manchester // 10
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: baud_rate_manchester
    gain: '1'
    samp_rate: samp_rate
    width: baud_rate_manchester // 5
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '5e-2'
    comment: |-
      tbh this block sucks for OOK
      because it tries to control when both On and Off
      really we should make a decision about on or off,
      then only control when On
    decay_rate: '1e-6'
    gain: '1'
    max_gain: '65536'
    reference: '3'
    type: float
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: AM demod (analog)
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: no separation, just append to file 1 packet (3 bytes) at a time
    file: /home/orville/Documents/tech/projects/cybersecurity/rf/toll-goodtogo/date20230411_rec2_trim_sego_reader.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/orville/Downloads/good2go/gqrx_2-hot.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      manchester decode
      0 is low->high
      1 is high->low
    m: '1'
    n: '2'
    offset: '0'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: each packet that we find becomes 3 bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: baud_rate_sego // 8
    type: byte
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.6'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '101010'
    type: float
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: decimate
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.2'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: channel_bw // baud_rate_manchester
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_offset
    decim: samp_rate // channel_bw
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_offset
    decim: samp_rate // channel_bw
    samp_rate: samp_rate
    taps: variable_band_pass_filter_taps_0
    type: ccc
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"2_agc-to-decimate"'
    size: int(channel_bw * timelen)
    srate: channel_bw
    tr_level: '13.0'
    type: float
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"4_after-threshold"'
    size: int(baud_rate_manchester * timelen)
    srate: channel_bw
    tr_level: '0'
    type: float
    ymax: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"3_decimate-to-threshold"'
    size: int(baud_rate_manchester * timelen)
    srate: baud_rate_manchester
    tr_level: '0'
    type: float
    ymax: '3'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '200'
    srate: baud_rate_manchester
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"1_demod-to-agc"'
    size: int(channel_bw * timelen)
    srate: samp_rate
    type: float
    ymax: '5'
  states: {}
- name: satellites_pdu_length_filter_0
  id: satellites_pdu_length_filter
  parameters:
    max: '-1'
    min: '0'
  states: {state: disabled}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    comment: |-
      use preamble and start delimiter (28 non-manchester bits) as sync word
      sync word is not included in output for this block
      next 24 bits (double bc of manchester) are included - this is enough for initialize command+CRC,
      part of group_select_eq command
      anything after the next 24 bits (until the next preamble) is not included in output
    packlen: 3*8*2
    sync: sync_word
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '3'
    sync: sync_word
    threshold: '4'
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', analog_agc2_xx_0, '0']
- [blocks_complex_to_mag_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_uchar_0, '0', satellites_sync_to_pdu_0, '0']
- [blocks_float_to_uchar_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [blocks_keep_m_in_n_1, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_keep_m_in_n_1, '0']
- [satellites_sync_to_pdu_0, out, blocks_message_debug_0, log]
- [satellites_sync_to_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_sync_to_pdu_packed_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
